<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Contatore a modulo 8.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Accendere Led quando si preme il bottone (con libreria)\prova.ewp</path>
    </project>
    <batchBuild />
</workspace>
