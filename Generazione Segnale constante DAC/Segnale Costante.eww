<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Generazione Sinusoide\Genrazione Sinusoide.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Segnale Constante.ewp</path>
    </project>
    <batchBuild />
</workspace>
